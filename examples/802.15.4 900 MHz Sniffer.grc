<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>IEEE_802_5_4_Sniffer</value></param>
<param><key>title</key><value>IEEE 802.15.4 Sniffer</value></param>
<param><key>author</key><value>Jay Kickliter</value></param>
<param><key>description</key><value>IEEE 802.15.4 Sniffer using OQPSK PHY</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_message</value></param>
<param><key>value</key><value>"hello"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>( 906 + 2*(channel-1)) * 1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2.4e6</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_samprate</value></param>
<param><key>note</key><value>Adjust sample rate as needed, standard compliant is 32e6 Hz</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>import</key><value>import ieee802_15_4</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value>bladerf</value></param>
<param><key>sync</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>rx_vga_gain_1</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>20</value></param>
</block>
<block>
<key>fosphor_wx_sink_c</key>
<param><key>id</key><value>fosphor_wx_sink_c_0</value></param>
<param><key>wintype</key><value>window.WIN_BLACKMAN_hARRIS</value></param>
<param><key>freq_center</key><value>freq</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
<param><key>grid_pos</key><value>[0,0,1,3]</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>online</value></param>
<param><key>label</key><value>Online</value></param>
<param><key>value</key><value>True</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>[2,0,1,1]</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>cur_freq</value></param>
<param><key>label</key><value>Current center frequency</value></param>
<param><key>value</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rx_vga_gain_1</value></param>
<param><key>label</key><value>TX/RX Gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>min</key><value>1</value></param>
<param><key>max</key><value>30</value></param>
<param><key>num_steps</key><value>30</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>[1,0,1,3]</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>channel</value></param>
<param><key>label</key><value>Channel</value></param>
<param><key>value</key><value>1</value></param>
<param><key>choices</key><value>[i for i in range(1, 10)]</value></param>
<param><key>labels</key><value>[i for i in range(1, 10)]</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>[2,1,1,2]</value></param>
</block>
<block>
<key>foo_periodic_msg_source</key>
<param><key>id</key><value>foo_periodic_msg_source_0</value></param>
<param><key>msg</key><value>pmt.intern("Hello World!")</value></param>
<param><key>interval</key><value>1000</value></param>
<param><key>quit</key><value>True</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>num</key><value>-1</value></param>
</block>
<block>
<key>ieee802_15_4_bqpsk_phy</key>
<param><key>id</key><value>ieee802_15_4_bqpsk_phy_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<connection><source_block_id>ieee802_15_4_bqpsk_phy_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>rxout</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>ieee802_15_4_bqpsk_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>fosphor_wx_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_periodic_msg_source_0</source_block_id><sink_block_id>ieee802_15_4_bqpsk_phy_0</sink_block_id><source_key>out</source_key><sink_key>txin</sink_key></connection>
<connection><source_block_id>ieee802_15_4_bqpsk_phy_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
