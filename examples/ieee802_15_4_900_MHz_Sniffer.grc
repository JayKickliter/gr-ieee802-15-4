<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ieee802_15_4_900MHz_sniffer</value></param>
<param><key>title</key><value>IEEE 802.15.4 900 MHz BPSK Sniffer</value></param>
<param><key>author</key><value>Jay Kickliter</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2.4e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>translate_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate*oversampling,  samp_rate*0.9/2, samp_rate*0.5/2, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_shift</value></param>
<param><key>value</key><value>-samp_rate*oversampling/4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>filter.firdes.root_raised_cosine( 4, 4, 1.0, .35, 11*32)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tune_freq</value></param>
<param><key>value</key><value>(906+2*(channel-1))*1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>oversampling</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>rf_source</value></param>
<param><key>label</key><value>RF Source</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>label0</key><value>Live</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>label1</key><value>Recorded</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>bpsk_const</value></param>
<param><key>sym_map</key><value>[0,1]</value></param>
<param><key>const_points</key><value>const_symbols</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio import filter</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/ieee802-15-4_BPSK_Packes_2.4MHz.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>const_points</value></param>
<param><key>label</key><value>Constellation Points</value></param>
<param><key>type</key><value>raw</value></param>
<param><key>value</key><value>[1, -1]</value></param>
<param><key>gui_hint</key><value>tabs@1</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>const_symbols</value></param>
<param><key>label</key><value>Constellation Symbols</value></param>
<param><key>type</key><value>raw</value></param>
<param><key>value</key><value>[1, -1]</value></param>
<param><key>gui_hint</key><value>tabs@1</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>channel</value></param>
<param><key>label</key><value>Channel</value></param>
<param><key>type</key><value>real</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>value</key><value>9</value></param>
<param><key>options</key><value>(1,2,3,4,5,6,7,8,9,10)</value></param>
<param><key>labels</key><value>("1","2","3","4","5","6","7","8","9","10")</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
</block>
<block>
<key>fosphor_qt_sink_c</key>
<param><key>id</key><value>fosphor_qt_sink_c_0</value></param>
<param><key>freq_center</key><value>tune_freq</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>tabs@0</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>chip_error_threshold</value></param>
<param><key>label</key><value>Chip Error Threshold</value></param>
<param><key>type</key><value>int</value></param>
<param><key>value</key><value>6</value></param>
<param><key>gui_hint</key><value>tabs@1</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_mu</value></param>
<param><key>label</key><value>Mu (default 0.25)</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>.25</value></param>
<param><key>gui_hint</key><value>tabs@1:0,1,1,1</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>balderf_rxvga</value></param>
<param><key>label</key><value>RX VGA Gain (5-30)</value></param>
<param><key>type</key><value>int</value></param>
<param><key>value</key><value>5</value></param>
<param><key>gui_hint</key><value>tabs@1:0,2,1,1</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freq_correction_hz</value></param>
<param><key>label</key><value>Frequency Correction (Hz)</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>-10000</value></param>
<param><key>gui_hint</key><value>tabs@1</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>num_tabs</key><value>3</value></param>
<param><key>label0</key><value>Spectrum</value></param>
<param><key>label1</key><value>Setup</value></param>
<param><key>label2</key><value>Constellation</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>1200</value></param>
<param><key>update_time</key><value>1/10</value></param>
<param><key>gui_hint</key><value>tabs@2</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value>bladerf</value></param>
<param><key>sync</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate*oversampling</value></param>
<param><key>freq0</key><value>tune_freq+freq_shift+freq_correction_hz</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>balderf_rxvga</value></param>
<param><key>if_gain0</key><value>balderf_rxvga</value></param>
<param><key>bb_gain0</key><value>20</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>int(oversampling)</value></param>
<param><key>taps</key><value>translate_taps</value></param>
<param><key>center_freq</key><value>-freq_shift</value></param>
<param><key>samp_rate</key><value>samp_rate*oversampling</value></param>
</block>
<block>
<key>zeromq_push_sink</key>
<param><key>id</key><value>zeromq_push_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5555</value></param>
<param><key>timeout</key><value>5</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>input_index</key><value>0 if rf_source == 0 else 1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>ieee_802_5_4_bpsk_rx_phy</key>
<param><key>id</key><value>ieee_802_5_4_bpsk_rx_phy_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>constellation_points</key><value>[ 1+0j, -1+0j ]</value></param>
<param><key>threshold</key><value>5</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>fosphor_qt_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>zeromq_push_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>ieee_802_5_4_bpsk_rx_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee_802_5_4_bpsk_rx_phy_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ieee_802_5_4_bpsk_rx_phy_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
