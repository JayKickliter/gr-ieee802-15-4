<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ieee_802_5_4_bpsk_rx_phy</value></param>
<param><key>title</key><value>IEEE 802.15.4 900 BPSK RX PHY</value></param>
<param><key>author</key><value>Jay Kickliter</value></param>
<param><key>description</key><value>IEEE 802.15.4 900 BPSK RX PHY</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>IEEE802.15.4</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>filter.firdes.root_raised_cosine( 4, 4, 1.0, .35, 11*32)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio import filter</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>value</key><value>2.4e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>ieee802_15_4_bpsk_packet_sink</key>
<param><key>id</key><value>ieee802_15_4_bpsk_packet_sink_0</value></param>
<param><key>th</key><value>threshold</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>10</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>600e3</value></param>
<param><key>alpha</key><value>.35</value></param>
<param><key>ntaps</key><value>11*32</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>constellation</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>message</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constellation</value></param>
<param><key>sym_map</key><value>[0,1]</value></param>
<param><key>const_points</key><value>constellation_points</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>constellation_points</value></param>
<param><key>label</key><value>Constellation Points</value></param>
<param><key>value</key><value>[ 1+0j, -1+0j ]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold</value></param>
<param><key>label</key><value>Chip Error Threshold</value></param>
<param><key>value</key><value>5</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>digital_mpsk_receiver_cc</key>
<param><key>id</key><value>digital_mpsk_receiver_cc_0</value></param>
<param><key>M</key><value>2</value></param>
<param><key>theta</key><value>0</value></param>
<param><key>w</key><value>cmath.pi/100.0</value></param>
<param><key>fmin</key><value>-0.5</value></param>
<param><key>fmax</key><value>0.5</value></param>
<param><key>mu</key><value>.25</value></param>
<param><key>gain_mu</key><value>0.01</value></param>
<param><key>omega</key><value>samp_rate/600e3</value></param>
<param><key>gain_omega</key><value>0.001</value></param>
<param><key>omega_relative_limit</key><value>0.001</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>label</key><value>symbols</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<connection><source_block_id>ieee802_15_4_bpsk_packet_sink_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>out</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>digital_mpsk_receiver_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_mpsk_receiver_cc_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>ieee802_15_4_bpsk_packet_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_mpsk_receiver_cc_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
